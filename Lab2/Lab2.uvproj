# Keil uVision project Lab2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Lab2
  c flags: Optim=1
  c include: ..\inc;..\driverlib;..\..\RTOS;..\Lab2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: ADC.c OS.c PLL.c Retarget.c ST7735.c UART.c ADC.h FIFO.h OS.h PLL.h ST7735.h UART.h startup.s cr4_fft_64_stm32.s osasm.s PID_stm32.s lab2.c ADC_SW.c ADC_SW.h
