# Keil uVision project SDC.uvproj, settings and files
target SDC (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SDC
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s eDisk.c PLL.c lab5.c ADC.c ADC_SW.c OS.c Retarget.c ST7735.c UART.c ADC.h ADC_SW.h edisk.h FIFO.h OS.h PLL.h ST7735.h UART.h efile.c efile.h osasm.s cr4_fft_64_stm32.s
